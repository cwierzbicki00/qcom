#include "qcc74x_mtimer.h"
#include "board.h"
#include "mbedtls/aes.h"
#include "mbedtls/sha1.h"
#include "mbedtls/sha256.h"
#include "mbedtls/sha512.h"
#include "mbedtls/entropy.h"
#include "mbedtls/ctr_drbg.h"
#include "mbedtls/platform.h"
#include "mbedtls/pk.h"
#include "mbedtls/pem.h"
#include "qcc74x_sec_aes.h"

#define ALIGN_UP(size, align) (((size) + (align)-1) & ~((align)-1))
#define MAX_LEN 256
#define HASH_LEN 32

const static char public_key_pem[] = {
	"-----BEGIN PUBLIC KEY-----\n"
	"MIIBIjANBgkqhkiG9w0BAQEFAAOCAQ8AMIIBCgKCAQEAz0UbPCywyFZCedfjCU+f\n"
	"ckyO2iqFnCCp8l0wfePZHl7ZlFkKyxe0mOgkqQm867SA2k67e5FnGYNUsuTcmEmD\n"
	"xlVoUEl2aDTy8MI+usuNhbjzl3hAoEmEwqUFe2A/ijvPXCnmCisVn7VzKp8hLIt9\n"
	"SHMByDn+xS8n3Zz3Nl5N/BlQjQB+WGH9Z7lXX5kWnpOj9VwrwhQzVMQGEkEZBRB1\n"
	"vivcT5ItxOnK3+gv9IO1xy3TnlX3v10tExCki9Y5iwZtLk0DZvYAyd2bmrpAVsdU\n"
	"EuHbOi6fZ/haF/c5tSWIqYJ2mPNHYIX7unwtcwkSJTZgbA6rxseiDAYPSavAdj5x\n"
	"tQIDAQAB\n"
	"-----END PUBLIC KEY-----\n"
};

/* This is an example of an RSA private key in plaintext for demonstration purposes only.
 * Never hardcode private keys in actual code due to security risks.
 *
const static char private_key_pem[] = {
    "-----BEGIN RSA PRIVATE KEY-----\n"
    "MIIEowIBAAKCAQEAz0UbPCywyFZCedfjCU+fckyO2iqFnCCp8l0wfePZHl7ZlFkK\n"
    "yxe0mOgkqQm867SA2k67e5FnGYNUsuTcmEmDxlVoUEl2aDTy8MI+usuNhbjzl3hA\n"
    "oEmEwqUFe2A/ijvPXCnmCisVn7VzKp8hLIt9SHMByDn+xS8n3Zz3Nl5N/BlQjQB+\n"
    "WGH9Z7lXX5kWnpOj9VwrwhQzVMQGEkEZBRB1vivcT5ItxOnK3+gv9IO1xy3TnlX3\n"
    "v10tExCki9Y5iwZtLk0DZvYAyd2bmrpAVsdUEuHbOi6fZ/haF/c5tSWIqYJ2mPNH\n"
    "YIX7unwtcwkSJTZgbA6rxseiDAYPSavAdj5xtQIDAQABAoIBAQCnpS2yLjOO1rZN\n"
    "9uAb19sPh/zDWUFYVtMexWFDcddbSTyTULH6MuJQCvQcBVRZEVZnPOdHuwO5DxCi\n"
    "4ZnLUyrScKI+ziyHfMxDD9nNHHcLgd0E1q7u9of7J56Xe/HozRebZAg8kTycQRc1\n"
    "kiAy92AOCXeXi9EVjF6iUSNjRkOtcxdheKgQNbSdkuqyPsECIDGUiApreVt1D5r4\n"
    "+8BRipbWW0N1PWN4th3kX60/rALCI560n0bV9SQjmOcENJG0CGDo4RrATFZ3ChXM\n"
    "1DophDSrcQfIgW9vzkGAhNDrbj8mspRAdqNFPJ9Det9vt8R/aC1iUr66N633cx/7\n"
    "ghx+LMTBAoGBAO7/rJxZJZq2BzvuifJ1XEtGj6YYmBDtaI6e012rw4glmLUi1sPJ\n"
    "fgqcHqE+4B3O7dsm3L1EaX8zr0FujRQa4wGqz7R8DLa+5sl7JZbKswg+63y12ZSw\n"
    "1OUgpO/sdq7/RQ1z4zNUeFXqCUMg50pi3/6/uTfjsm/Utf9jFoQtlCazAoGBAN4D\n"
    "oUM9JBlZB3O85NutHNMOzP2lwfRHxvNuEH9mOrqXoy2V+LmyWmkNUqEGpueRcrvY\n"
    "nQbqPfcpMFiKzPFQy3YX/swq71xqxyjdnqx+kI6rXg1COH2I3TX+8NeTXqszdygl\n"
    "FmWC0eUtICTDm9lD3DskLlkqc1m0uAiRCJAfM/n3AoGAaBB7oDhQ32STEc1z01a2\n"
    "sTAwLCpZTEWTWUZe0lKP+SAltflNekKp1wTTcXJnM5N+jgYF54N6TCC9FsiENVTf\n"
    "s0Ik3nmFL60/4Er2uwnXmqeK8epcqxm0GXB1YOKdauVLs+fZ7efB3ebh0ZDqJMGY\n"
    "ttvUUjma4IbGGEWU8EjIUXECgYAy2D/5Zyo6R+JmBi+fg8DjMTOPL4QAzuNoYp+S\n"
    "nbX7f7jWOs9wr8D26B8xU5Wr2OqezJgBummgjiVNUdRnu6otDIfE+FxDHQ0pdb/e\n"
    "H0o58lMi1DSdw1duA0njBRQcPzgd0IiVjOVHCBOhd87cbickwD+BGjC6raGsDJMa\n"
    "dprvtwKBgFHdKmuAAfdyJaHYUFYnRBKctK8JsunOB9TqtM4nI7UNQWsGo4o6rt8W\n"
    "3YMdbngWbYmrfKaNwYiyYnVhtF7s6swTIYb6T3k8DTrDVk+pBrRjsscrc33MOjho\n"
    "B6kuQkTsfp7G3Cd3sW9r2tIxzE4sOJpXClX9Il57P4apK84ENw2w\n" 
    "-----END RSA PRIVATE KEY-----\n"                       
};
*/

/**
 * This is the ciphertext of private_key_pem.
 */
const static char private_key_pem_ciphertext[] = {
	0x93,0x48,0x04,0x33,0x9E,0x91,0x43,0xE1,0xBD,0x33,0x9C,0xE5,0x3A,0xD9,0x17,0x8F,0x88,0x9F,0x76,0xE0,0xA1,0x6F,0xED,0x89,0x9C,0x19,0x36,0x13,0x92,0xA0,0x79,0xBE,0x8E,
	0xB2,0x13,0x35,0xF8,0x47,0xE8,0x15,0x21,0x2B,0xFD,0x70,0xA7,0x00,0x5E,0xC6,0xD4,0xB2,0x2E,0x6C,0x2D,0xD1,0xFB,0xED,0xBE,0xE3,0xE6,0x5F,0x71,0x66,0xD4,0x65,0xE6,
	0x03,0x45,0x52,0x0F,0x52,0x4F,0x2B,0xEF,0x9E,0x27,0x65,0x89,0x44,0xEC,0x63,0xCD,0x45,0x1C,0x3A,0x5D,0xBE,0xA2,0x65,0xD2,0xFF,0xA1,0x43,0xA4,0x50,0x3E,0xC2,0x86,
	0x3C,0x5F,0xF8,0x37,0x9F,0x06,0xF8,0xCB,0x4D,0x44,0x0C,0x4D,0xAE,0x7F,0xA1,0xD8,0x3A,0xC4,0x0C,0xF4,0x46,0x81,0x61,0x7D,0x30,0xDB,0xCC,0x75,0xA1,0x2F,0xB2,0x28,
	0xB9,0x92,0x1D,0xA4,0x9B,0xBC,0x7F,0xD4,0xA2,0xDB,0x94,0x9A,0xC1,0x60,0x7E,0x3B,0xF1,0xDA,0xD6,0x8E,0x09,0x57,0x2B,0x4B,0xCD,0x34,0x2E,0x6B,0x4D,0xB5,0x31,0xC8,
	0x84,0xA5,0x41,0x60,0x47,0x09,0x99,0x69,0x3F,0xE1,0x57,0xDA,0xF3,0x88,0xCE,0x96,0x71,0x0B,0x05,0x82,0x16,0xDD,0xFC,0x2D,0xE9,0x72,0xBF,0x22,0xE2,0xAE,0xED,0x59,
	0x8B,0x44,0x9D,0xDA,0x1C,0x6F,0x7A,0x9F,0x52,0xDC,0xDB,0x0A,0x46,0x9C,0xC6,0x5A,0x85,0xB5,0x3E,0x2C,0xBB,0x04,0x83,0x3A,0x9C,0x81,0x7F,0xBF,0x02,0x42,0x06,0x8D,
	0x3D,0xAE,0x47,0xAB,0x45,0x20,0x67,0x67,0x72,0x10,0x04,0xC1,0xAB,0xA2,0x72,0x91,0x6B,0xE3,0xB4,0x3E,0x6C,0x7A,0x93,0xB4,0xA9,0x04,0x44,0x52,0x5E,0x2E,0xD8,0xA8,
	0x7D,0xD2,0x84,0xD6,0xA5,0x4A,0x8C,0xFD,0x06,0xDD,0xDD,0x13,0x86,0x85,0x88,0xAE,0xB3,0x64,0x44,0xD2,0xDE,0x03,0x10,0x4E,0x27,0x4F,0x66,0xA8,0xAF,0x6E,0x2C,0x44,
	0xE1,0x96,0x2C,0xF7,0x6F,0x90,0xCE,0xC0,0x69,0x9C,0x63,0xBF,0xA7,0xCA,0xEE,0x89,0xEA,0x60,0xDA,0x7A,0x4E,0x23,0xA3,0x0F,0x55,0xCB,0x17,0x07,0x8E,0x44,0x8D,0x1A,
	0x14,0x5A,0x26,0x27,0x2C,0xC5,0x4E,0x21,0xC7,0x3E,0x28,0xC5,0xDB,0xC7,0xE1,0x22,0xC2,0xBE,0xDE,0xC1,0xAE,0x3A,0xC3,0xE5,0x21,0x96,0x61,0x57,0x05,0x49,0x92,0x48,
	0x78,0xA4,0x32,0xA1,0xAD,0x24,0xAB,0x5F,0xF6,0xC2,0x39,0x4B,0xC8,0xC9,0x95,0x33,0x8A,0xCC,0xB6,0x67,0xFB,0x4C,0x42,0x71,0xA3,0x59,0x0D,0x6B,0x51,0x02,0xEA,0xD9,
	0x15,0xC7,0xE2,0xFA,0xF7,0xE3,0xB8,0xF5,0x44,0xB4,0x35,0xCD,0x75,0xDB,0x82,0x86,0x86,0x79,0x66,0xFF,0xA4,0xC0,0x87,0x18,0x39,0x96,0x95,0x1E,0x9C,0x2F,0x38,0x45,
	0xE0,0xC9,0x4F,0xBB,0x82,0x60,0x33,0xE6,0xE7,0x79,0x4D,0x4C,0xE8,0x7B,0x04,0x54,0x35,0x1D,0x64,0xAD,0x39,0xFF,0x66,0xF9,0x1A,0xC4,0xBB,0x09,0x27,0x59,0x10,0x84,
	0x7C,0xF2,0x39,0xD9,0x17,0x2B,0xEF,0xE5,0x73,0xB2,0x7C,0x20,0x93,0xC2,0x1B,0x1F,0x5E,0xCA,0xAA,0x64,0xDF,0xE6,0xA3,0x31,0x3B,0xFC,0x9C,0xDA,0xF8,0x24,0x45,0xD1,
	0x85,0xB1,0x86,0xC5,0x47,0xE8,0xAF,0x52,0xE6,0x92,0x02,0x2F,0x21,0xED,0x7C,0xCF,0x68,0x80,0x73,0x66,0x55,0xB5,0x07,0xBF,0xB7,0x21,0xEA,0x45,0x3B,0x74,0x73,0xEC,
	0x34,0xB5,0x40,0x93,0x3E,0x47,0x87,0xD8,0xA9,0x47,0x24,0x73,0xE0,0xDF,0x5F,0x44,0x26,0x61,0x30,0x8A,0x0C,0x55,0xFF,0xC1,0xB0,0x62,0xC2,0xEF,0xA1,0xE8,0xCC,0x62,
	0xD1,0x0F,0xEE,0x22,0x86,0x00,0xFE,0xCB,0x17,0xD8,0xC4,0x81,0x1D,0x75,0x81,0x99,0xAD,0x32,0x61,0x22,0xFD,0xAC,0x89,0xB2,0x49,0x35,0x94,0x1A,0xC1,0xC5,0xFA,0xEE,
	0x5C,0xD1,0x78,0xBC,0x54,0x85,0x60,0x52,0xCD,0x2A,0x67,0xDF,0xCC,0x36,0xE2,0x4D,0x80,0x41,0xB5,0x4F,0xDF,0x67,0x79,0x62,0x13,0x33,0x6B,0xFC,0x97,0x3A,0x87,0xFC,
	0x55,0xC0,0x4C,0xCB,0x2C,0x86,0xD5,0xD8,0xE9,0xFF,0xD3,0xEF,0x67,0x34,0xA6,0x07,0x06,0xAB,0x57,0xD0,0x7C,0x21,0xAD,0xD7,0xC2,0x11,0x9E,0x80,0x73,0x37,0x32,0x1C,
	0x4E,0x74,0x83,0xC4,0x9A,0xA5,0xFF,0x05,0x83,0x6D,0xB2,0x80,0x0A,0x88,0xA4,0x60,0x1C,0x91,0x7C,0x22,0x69,0xFC,0x20,0x98,0x80,0x3B,0x2F,0x94,0x38,0x06,0x04,0x5D,
	0xE6,0xD2,0x45,0xA3,0x8A,0x8D,0xBE,0x17,0x79,0x73,0x65,0xFD,0x09,0x45,0x5A,0xAA,0xFF,0x44,0xFF,0x93,0x1C,0x69,0xA8,0x1C,0xE6,0xAF,0x9E,0x29,0x02,0x5C,0x35,0x23,
	0xF1,0x31,0x72,0x6E,0xB1,0x7E,0x98,0xCA,0x81,0x3F,0x9C,0x09,0x6D,0x52,0xCF,0x33,0x79,0xCF,0xEE,0xD9,0x74,0x70,0xE3,0x06,0x49,0xA7,0xD2,0xAA,0x3F,0x98,0xF5,0x73,
	0x5D,0xA1,0x33,0xE1,0x5C,0x89,0x70,0xDD,0x9D,0x66,0x50,0xEA,0x91,0x7E,0xA6,0xBA,0x5A,0x55,0xB8,0x4D,0x27,0x29,0x82,0x9A,0x5C,0x18,0xD6,0x2E,0x8E,0x44,0x1C,0xE3,
	0x03,0x35,0x4B,0x3A,0xFE,0xA3,0xFF,0x33,0x8B,0x44,0x38,0x20,0xA2,0x0D,0xC0,0xCB,0xB1,0x25,0xE7,0x36,0xFD,0xA9,0xF9,0x61,0x04,0x82,0x4D,0x67,0xEA,0xC9,0x22,0xA4,
	0x19,0xDD,0x84,0x5C,0xDA,0xEB,0x08,0x2B,0x71,0x71,0x62,0x5E,0x83,0x0F,0xB4,0x05,0x45,0x9C,0x5F,0x95,0x67,0x8C,0xB0,0x1C,0xCC,0xA8,0xB4,0xDD,0x04,0x06,0x93,0x88,
	0xCE,0x91,0xD6,0x92,0x2E,0x88,0x71,0x72,0x32,0x28,0x27,0xD8,0x00,0x5B,0x9D,0x76,0x0D,0x32,0x60,0x0A,0x17,0x9C,0x4F,0x4C,0x24,0x7D,0x51,0xC7,0xEC,0xFF,0x9D,0x9E,
	0x00,0x52,0xD3,0x84,0x07,0x37,0x14,0xD5,0x4F,0x72,0xFA,0xFF,0x2D,0x7C,0x3E,0x47,0xFD,0x94,0x4E,0xB7,0xD3,0x58,0x37,0x2C,0x35,0x7A,0x56,0xD0,0xEE,0xA6,0x46,0x40,
	0x0C,0x31,0xF7,0xF4,0x8C,0x7A,0x94,0x10,0x42,0x94,0x7A,0x71,0x68,0x89,0x9C,0xC3,0x0F,0xD5,0x10,0xDB,0x32,0x1A,0x4F,0x29,0x4F,0xB6,0x5B,0x8D,0x67,0xEC,0x81,0x21,
	0xFE,0x1F,0x63,0x23,0x40,0xF8,0x8F,0xF5,0x9B,0x30,0x44,0x90,0xD9,0xE1,0xA9,0x8B,0xBD,0x35,0xA5,0x03,0x44,0x9E,0xAF,0xBC,0x9F,0xB7,0x8C,0x9A,0x72,0xA2,0xAF,0xE7,
	0x54,0xE3,0x73,0x33,0x67,0xD1,0xA6,0x4E,0x5C,0x31,0x08,0x21,0xAE,0x95,0x36,0x24,0xF8,0x30,0xAD,0x2B,0xD0,0x39,0x56,0x40,0x01,0x3F,0x60,0xF5,0x92,0x79,0x45,0x2A,
	0x4E,0x85,0xF9,0x19,0x81,0x61,0x2A,0xB9,0xB4,0x39,0x97,0x6A,0x7F,0x92,0x42,0xF1,0xF4,0xE0,0x54,0x5D,0x0A,0x19,0xE7,0x85,0x73,0x84,0x68,0x87,0x62,0x8C,0xEC,0x03,
	0x21,0x86,0xBD,0x6A,0x66,0x18,0x1E,0xA7,0xD3,0x6B,0x53,0x81,0x6D,0x90,0x66,0x74,0x16,0x60,0x94,0x43,0x6F,0x53,0xC5,0xF5,0x1B,0x2D,0x03,0x43,0xFA,0x11,0x7B,0x5F,
	0xB5,0x64,0xC7,0xCB,0xC0,0x84,0xFD,0x7C,0xD4,0x68,0xDD,0x5F,0xC5,0x28,0x58,0xA1,0xCE,0xBA,0x1A,0xF6,0xE9,0xC7,0x40,0xF8,0x39,0x2F,0xEC,0xB9,0xAE,0x70,0x72,0x21,
	0xA8,0xC0,0x29,0xE7,0x09,0x81,0x4B,0x06,0x99,0x00,0x32,0xCE,0xD8,0xFD,0x18,0x2D,0xD5,0x4A,0x86,0xC8,0x87,0xB4,0xCD,0x94,0x1B,0x88,0xD7,0x27,0xDE,0xCB,0xB3,0x3F,
	0x14,0x1A,0x25,0xC1,0xA0,0xC0,0xFF,0xA1,0x85,0x7C,0x23,0x30,0x1A,0xE7,0x74,0x0B,0x4A,0x14,0x09,0x25,0x89,0xB8,0x28,0x27,0xD4,0xA2,0x31,0x65,0xF8,0xDF,0x94,0x74,
	0x50,0xDF,0x6B,0xC8,0x13,0x6A,0x7D,0xFC,0xD7,0xCC,0xA8,0x7F,0xBD,0x8F,0xF3,0x18,0x9A,0x00,0x6F,0x23,0x7F,0x02,0x42,0xFE,0x78,0xAD,0xB7,0xD1,0x20,0xBE,0x1E,0xB7,
	0xF3,0x48,0x6D,0xAF,0x67,0x2E,0xFE,0xDD,0x8F,0x61,0xA1,0xD0,0xFC,0xDB,0x7D,0x0A,0x14,0x27,0xFC,0xE1,0x41,0xB7,0xA8,0x00,0x6E,0xAD,0x5D,0x64,0xEA,0xEF,0xD0,0x19,
	0x16,0xEB,0x32,0x2C,0x1E,0x34,0xF1,0xB1,0x22,0xF2,0xA2,0xF3,0x4C,0x44,0x95,0x6B,0xF8,0x26,0xF1,0xBC,0xB9,0xE5,0xF5,0x41,0xDE,0xD8,0xB9,0xE4,0x13,0xFD,0x59,0x0C,
	0x02,0x00,0x93,0xA4,0xE0,0xD1,0xCE,0xDD,0x71,0x5E,0x17,0x79,0xEA,0x3F,0xB0,0x4A,0x5A,0x7C,0xEA,0x5A,0xC0,0xDE,0xC9,0xD8,0xFC,0x6C,0x46,0x2F,0x69,0xFE,0x7E,0xB1,
	0x24,0xA4,0xF7,0x9D,0x26,0x4E,0xD0,0x4C,0x34,0x1F,0xAD,0x50,0x08,0x85,0xB5,0x42,0x90,0xE0,0x2A,0x7B,0xA4,0x4F,0x86,0x59,0x00,0xE0,0x0E,0x9F,0xDE,0x39,0x33,0x76,
	0x59,0xF4,0x54,0xA7,0x19,0x26,0x24,0x83,0xFE,0x06,0x43,0x56,0xEA,0x22,0x88,0x6A,0x10,0x02,0x5F,0xB6,0x8F,0xA5,0x83,0x4D,0xA8,0x71,0x34,0x07,0x43,0xA2,0xB8,0x50,
	0xB5,0xBC,0x7F,0x88,0x25,0xA5,0x91,0xB9,0x8F,0x2A,0xC2,0xC4,0xD0,0x4F,0x5D,0xAD,0x39,0x0C,0x08,0x2F,0x71,0x56,0xAC,0x47,0x5D,0xC2,0x13,0x66,0x03,0x1A,0x94,0x0E,
	0x4F,0x1A,0xAA,0x41,0xA3,0x88,0xC6,0x62,0xAE,0xD8,0x75,0x62,0x2C,0xA8,0x34,0xB8,0x1E,0x40,0x5A,0x03,0xD5,0x78,0xB0,0x03,0xB0,0x81,0xF5,0x8C,0x5D,0x30,0xAB,0x98,
	0x16,0x29,0xFC,0xA0,0xFF,0xAA,0xB7,0x4B,0x50,0x5D,0xFD,0xFE,0xF8,0x74,0x82,0xBF,0x31,0xCE,0x38,0x43,0x6A,0x7D,0x66,0x8D,0xE7,0x95,0xDD,0x47,0xED,0xEC,0x69,0xD4,
	0xB3,0x62,0x12,0x5B,0x85,0xF9,0x47,0xEA,0x1C,0x65,0xF2,0x40,0xDA,0xFC,0x03,0x94,0x76,0x63,0xAD,0x95,0xFB,0x91,0x4C,0x2C,0xCF,0xBE,0xE9,0xBD,0xFD,0x27,0xBB,0xF4,
	0x68,0xF2,0x85,0x1D,0xB7,0xC4,0x6C,0xD6,0x06,0x73,0x24,0xBC,0xAF,0x3D,0xBF,0x6E,0xD3,0x9C,0x56,0x2D,0x6D,0x2E,0xD6,0xD4,0xF5,0x85,0x12,0x1D,0xCD,0x6C,0xC9,0x1C,
	0x5F,0xB5,0xAD,0x3B,0xA1,0xA5,0xD6,0x43,0x76,0xD1,0x85,0xC5,0x0A,0x8C,0x76,0x4D,0x31,0x88,0x71,0xBD,0x67,0x3A,0xF3,0xE4,0x96,0xA0,0x9A,0x5B,0xD6,0x1B,0x2B,0xB3,
	0x83,0x14,0xE1,0xF3,0xEC,0xA7,0x67,0x92,0x92,0x94,0x1E,0xFD,0xBE,0x00,0xD1,0x4C,0x4D,0xFB,0x8B,0x60,0x7D,0xA6,0xFB,0x4D,0x4D,0x15,0x7C,0xBA,0x3F,0xD0,0x32,0xB8,
	0xF4,0x30,0x95,0xF8,0x26,0x87,0xAE,0xA4,0x2F,0x30,0x67,0x54,0x8E,0x16,0x61,0x33,0xA0,0xB2,0x23,0xB6,0x2E,0xFE,0x48,0x76,0xF3,0xEB,0x0C,0xB2,0x61,0xB8,0x22,0xE8,
	0xB9,0x2D,0xB5,0x11,0xCC,0x80,0x97,0x82,0x66,0x93,0x5F,0x4A,0xA9,0xDC,0x9D,0x79,0x1F,0x48,0x97,0x24,0x64,0x2A,0xB0,0x53,0xCB,0xD5,0xEF,0x32,0x0E,0x2F,0x0A,0x6D,
	0x5A,0x87,0xF9,0x25,0x85,0x29,0x94,0xCA,0x65,0xDA,0x21,0xF9,0x1F,0x0A,0xD3,0x57,0x1B,0xE3,0x9A,0xFF,0x8E,0x3E,0x2F,0xA7,0x7A,0x43,0x36,0xCD,0xD9,0x9C,0x73,0x2B,
	0xE0,0x56,0x65,0xEA,0x2D,0x79,0x41,0x22,0x6D,0x36,0x87,0xA5,0xD8,0x9A,0x59,0x0E,0x3E,0xCC,0xEB,0x37,0x98,0x72,0xB7,0x3D,0x29,0xB1,0x9C,0x5B,0x60,0xF1,0x02,
};

static void print_hex(const char *label, const unsigned char *buf, size_t len)
{

    printf("%s: ", label);

    for (size_t i = 0; i < len; i++) {

        printf("0x%02X,", buf[i]);

        if (i && (i%32==0)) {
        	printf("\r\n");
        }
    }                                                    
    printf("\n");                                        
}

static const uint8_t aes_ecb_128bit_iv[16] = {
    { 0 },
};

static int aes_hw_aes_decrypt(const uint8_t *input, size_t ilen, uint8_t *output, size_t olen)
{
	int ret;
	size_t len;
    struct qcc74x_device_s *aes;
    uint8_t *enc_buffer;

    /* Note: The eFuse operations documented here are for illustrative purposes only.
     * In a real implementation, the AES key must remain inaccessible to application code.
     */
    struct qcc74x_device_s *efuse_dev = qcc74x_device_get_by_name("ef_ctrl");
    const uint8_t aes_key_tmp[16] = {
        0x2b, 0x7e, 0x15, 0x16, 0x28, 0xae, 0xd2, 0xa6,
        0xab, 0xf7, 0x15, 0x88, 0x09, 0xcf, 0x4f, 0x3c,
    };
    //print_hex("aes_key_tmp", aes_key_tmp, 16);
    qcc74x_ef_ctrl_write_direct(efuse_dev, 0x4c, (uint32_t *)(aes_key_tmp), 4, 1);     /* slot 3*/
    //qcc74x_ef_ctrl_write_direct(efuse_dev, 0x3c, (uint32_t *)(aes_key_tmp), 4, 1);   /* slot 2*/
    memset(aes_key_tmp, 0, sizeof(aes_key_tmp));
    qcc74x_ef_ctrl_read_direct(NULL, 0x4c, (uint32_t *)aes_key_tmp, 4, 1);
    //print_hex("slot3", aes_key_tmp, 16);

    aes = qcc74x_device_get_by_name("aes");
    qcc74x_aes_link_deinit(aes);
    qcc74x_group0_request_aes_access(aes);
    qcc74x_aes_init(aes);
    qcc74x_aes_set_hwkey_source(aes, 0);

    /* keysel0 = 0, keysel1 = 0*/
    qcc74x_aes_select_hwkey(aes, 0, 0);
    qcc74x_aes_set_mode(aes, AES_MODE_ECB);
    qcc74x_aes_setkey(aes, NULL, 128);

    len = ALIGN_UP(ilen, 32);

    enc_buffer = memalign(32, len);
    if (enc_buffer == NULL) {
    	printf("malloc buffer fail\r\n");
    	goto _exit;
    }
    memset(enc_buffer, 0, len);
    memcpy(enc_buffer, input, ilen);

    qcc74x_l1c_dcache_clean_invalidate_range(enc_buffer, len);
    qcc74x_l1c_dcache_clean_invalidate_range(output, ALIGN_UP(olen, 32));

    //print_hex("ENC", enc_buffer, len);

    printf("aes ecb128 encrypt success\r\n");

    qcc74x_aes_decrypt(aes, enc_buffer, aes_ecb_128bit_iv, output, len);

    //print_hex("DEC", output, len);

    free(enc_buffer);
_exit:

    return ret;
}

void mbedtls_rsa_test(void)
{                                                        
    int ret;                                             
    size_t olen;                                         
    mbedtls_pk_context pk_public, pk_private;
    mbedtls_entropy_context entropy;
    mbedtls_ctr_drbg_context ctr_drbg;
    size_t input_len, pem_len;
    const char *pers = "rsa_encryption_example";         
    unsigned char message[] = "Hello, RSA encryption!";
    static unsigned char encrypted[MAX_LEN] = {0};
    static unsigned char decrypted[MAX_LEN] = {0};
    static unsigned char hash[HASH_LEN] = {0};
    static unsigned char signature[MBEDTLS_MPI_MAX_SIZE] = {0};
    size_t sig_len = 0;
    uint8_t *pk_private_pem;

    // Initialize contexts
    mbedtls_pk_init(&pk_public);
    mbedtls_pk_init(&pk_private);
    mbedtls_entropy_init(&entropy);
    mbedtls_ctr_drbg_init(&ctr_drbg);

    // Seed the random number generator
    if ((ret = mbedtls_ctr_drbg_seed(&ctr_drbg, mbedtls_entropy_func, &entropy, (const unsigned char *)pers, strlen(pers))) != 0) {
        printf("Failed to seed DRBG: -0x%04x\n", -ret);
        goto exit;
    }

    if ((ret = mbedtls_pk_parse_public_key(&pk_public, public_key_pem, sizeof(public_key_pem))) != 0) {
        printf("Failed to load public key %lx\n", -ret);
        goto exit;
    }

    pem_len = sizeof(private_key_pem_ciphertext);
    pk_private_pem = memalign(32, ALIGN_UP(pem_len, 32));
    memset(pk_private_pem, 0, ALIGN_UP(pem_len, 32));

    aes_hw_aes_decrypt(private_key_pem_ciphertext, pem_len, pk_private_pem, ALIGN_UP(pem_len, 32));

    //printf("PK %d %d: %s", pem_len, strlen(pk_private_pem) + 1, pk_private_pem);
    if ((ret = mbedtls_pk_parse_key(&pk_private, pk_private_pem, strlen(pk_private_pem) + 1, NULL, 0)) != 0) {
        printf("Failed to load private key %lx\n", -ret);
        goto exit;
    }
    memset(pk_private_pem, 0, pem_len);
    free(pk_private_pem);

    if ((ret = mbedtls_pk_check_pair(&pk_public, &pk_private)) != 0) {
        printf("Public and private key check failed: %lx\n", -ret);
        goto exit;
    }

    input_len = strlen((char *)message);

    printf("Original message: %s\n", message);
    print_hex("Original data", message, input_len);

    // Encrypt using public key
    ret = mbedtls_pk_encrypt(&pk_public, message, strlen((const char *)message), encrypted, &olen, sizeof(encrypted), mbedtls_ctr_drbg_random, &ctr_drbg);
    if (ret != 0) {
        printf("Encryption failed: -0x%04x\n", -ret);
        goto exit;
    }

    printf("Encrypted message length: %lu\n", olen);

    // Decrypt using private key
    ret = mbedtls_pk_decrypt(&pk_private, encrypted, olen, decrypted, &olen, sizeof(decrypted), mbedtls_ctr_drbg_random, &ctr_drbg);
    if (ret != 0) {
        printf("Decryption failed: -0x%04x\n", -ret);
        goto exit;
    }

    decrypted[olen] = '\0'; // Null-terminate the string

    printf("Decrypted message: %s\n", decrypted);

    // Create SHA-256 hash of message
    mbedtls_md(mbedtls_md_info_from_type(MBEDTLS_MD_SHA256), message, strlen((const char *)message), hash);

    // Sign the hash with private key
    ret = mbedtls_pk_sign(&pk_private, MBEDTLS_MD_SHA256, hash, 0, signature, &sig_len, mbedtls_ctr_drbg_random, &ctr_drbg);
    if (ret != 0) {
        printf("Signing failed: -0x%04x\n", -ret);
        goto exit;
    }

    printf("Signature length: %lu\n", sig_len);

    // Verify the signature with public key
    ret = mbedtls_pk_verify(&pk_public, MBEDTLS_MD_SHA256, hash, 0, signature, sig_len);
    if (ret != 0) {
        printf("RSA signature verification failed: -0x%04x\n", -ret);
    } else {
        printf("RSA signature verification successful.\n");
    }

exit:
    // Free resources
    mbedtls_pk_free(&pk_public);
    mbedtls_pk_free(&pk_private);
    mbedtls_ctr_drbg_free(&ctr_drbg);
    mbedtls_entropy_free(&entropy);
}
